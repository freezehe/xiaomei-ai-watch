/*
 * SPDX-FileCopyrightText: 2025
 *
 * SPDX-License-Identifier: Apache-2.0
 */
#include <cstdio>
#include <ctime>
#include "lvgl.h"
#include "esp_brookesia.hpp"
#ifdef ESP_UTILS_LOG_TAG
#   undef ESP_UTILS_LOG_TAG
#endif
#define ESP_UTILS_LOG_TAG "BS:Clock"
#include "esp_lib_utils.h"
#include "sys_battery.h"
#include "sys_net.h"
#include "sys_time.h"
#include "lunar.h"
#include "esp_brookesia_app_clock.hpp"

#define APP_NAME "Clock"

LV_IMG_DECLARE(esp_brookesia_app_icon_clock);
// Subset fonts, generated by tools/make_clock_fonts.py
LV_FONT_DECLARE(clock_font_cn_28);
LV_FONT_DECLARE(clock_font_cn_20);
LV_FONT_DECLARE(clock_font_digits_120);

using namespace std;
using namespace esp_brookesia::gui;
using namespace esp_brookesia::systems;

namespace esp_brookesia::apps {

// Palette (AMOLED: pure black background, black pixels are off)
constexpr uint32_t COLOR_TEXT      = 0xFFFFFF;
constexpr uint32_t COLOR_TEXT_DIM  = 0x9A9AA5;
constexpr uint32_t COLOR_OFF       = 0x48484A;
constexpr uint32_t COLOR_TRACK     = 0x1C1C22;
constexpr uint32_t COLOR_ACCENT    = 0xFF9F0A;
constexpr uint32_t COLOR_LUNAR     = 0xD9B26F;
constexpr uint32_t COLOR_OK        = 0x30D158;
constexpr uint32_t COLOR_ERROR     = 0xFF453A;

constexpr int SCREEN_SIZE      = 466;
constexpr int RING_SIZE        = 448;
constexpr int RING_WIDTH       = 6;
constexpr int DIAL_SIZE        = 440;
constexpr int HOUR_HAND_LEN    = 105;
constexpr int MIN_HAND_LEN     = 160;
constexpr int SEC_HAND_LEN     = 185;
constexpr uint32_t TIMER_MS    = 200;   // Poll often, redraw only when the second changes

static const char *const WEEKDAYS[] = { "日", "一", "二", "三", "四", "五", "六" };
static const char *DIAL_LABELS[] = {
    "12", "1", "2", "3", "4", "5", "6", "7", "8", "9", "10", "11", "12", nullptr
};

Clock *Clock::_instance = nullptr;
Clock::Face Clock::_face = Clock::FACE_DIGITAL;

Clock *Clock::requestInstance()
{
    if (_instance == nullptr) {
        _instance = new Clock();
    }
    return _instance;
}

// name="Clock", launcher_icon=esp_brookesia_app_icon_clock (assets/, generated by tools/make_icons.py),
// use_default_screen=true, no status bar and no navigation bar: the face uses the whole round screen
Clock::Clock():
    App(APP_NAME, &esp_brookesia_app_icon_clock, true, false, false)
{
}

Clock::~Clock()
{
}

static lv_obj_t *create_box(lv_obj_t *parent)
{
    lv_obj_t *obj = lv_obj_create(parent);
    lv_obj_remove_style_all(obj);
    lv_obj_remove_flag(obj, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_remove_flag(obj, LV_OBJ_FLAG_SCROLLABLE);
    return obj;
}

static lv_obj_t *create_label(lv_obj_t *parent, const lv_font_t *font, uint32_t color, int y)
{
    lv_obj_t *label = lv_label_create(parent);
    lv_obj_set_style_text_font(label, font, 0);
    lv_obj_set_style_text_color(label, lv_color_hex(color), 0);
    lv_obj_set_style_text_align(label, LV_TEXT_ALIGN_CENTER, 0);
    lv_label_set_text(label, "");
    lv_obj_align(label, LV_ALIGN_CENTER, 0, y);
    return label;
}

void Clock::createDigitalFace(lv_obj_t *parent)
{
    _digital = create_box(parent);
    lv_obj_set_size(_digital, LV_PCT(100), LV_PCT(100));

    // Seconds ring along the edge of the round screen, with a glowing knob at the current second
    _sec_arc = lv_arc_create(_digital);
    lv_obj_remove_flag(_sec_arc, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_set_size(_sec_arc, RING_SIZE, RING_SIZE);
    lv_obj_center(_sec_arc);
    lv_arc_set_rotation(_sec_arc, 270);
    lv_arc_set_bg_angles(_sec_arc, 0, 360);
    lv_arc_set_range(_sec_arc, 0, 60);
    lv_arc_set_value(_sec_arc, 0);
    lv_obj_set_style_arc_width(_sec_arc, RING_WIDTH, LV_PART_MAIN);
    lv_obj_set_style_arc_color(_sec_arc, lv_color_hex(COLOR_TRACK), LV_PART_MAIN);
    lv_obj_set_style_arc_width(_sec_arc, RING_WIDTH, LV_PART_INDICATOR);
    lv_obj_set_style_arc_color(_sec_arc, lv_color_hex(COLOR_ACCENT), LV_PART_INDICATOR);
    lv_obj_set_style_arc_rounded(_sec_arc, true, LV_PART_INDICATOR);
    lv_obj_set_style_bg_color(_sec_arc, lv_color_hex(COLOR_ACCENT), LV_PART_KNOB);
    lv_obj_set_style_pad_all(_sec_arc, 3, LV_PART_KNOB);
    lv_obj_set_style_shadow_width(_sec_arc, 12, LV_PART_KNOB);
    lv_obj_set_style_shadow_color(_sec_arc, lv_color_hex(COLOR_ACCENT), LV_PART_KNOB);
    lv_obj_set_style_shadow_opa(_sec_arc, LV_OPA_60, LV_PART_KNOB);

    // WiFi + battery row
    lv_obj_t *row = create_box(_digital);
    lv_obj_set_size(row, LV_SIZE_CONTENT, LV_SIZE_CONTENT);
    lv_obj_set_flex_flow(row, LV_FLEX_FLOW_ROW);
    lv_obj_set_flex_align(row, LV_FLEX_ALIGN_CENTER, LV_FLEX_ALIGN_CENTER, LV_FLEX_ALIGN_CENTER);
    lv_obj_set_style_pad_column(row, 16, 0);
    lv_obj_align(row, LV_ALIGN_CENTER, 0, -165);
    _wifi_label = lv_label_create(row);
    lv_obj_set_style_text_font(_wifi_label, &lv_font_montserrat_20, 0);
    lv_label_set_text(_wifi_label, LV_SYMBOL_WIFI);
    _battery_label = lv_label_create(row);
    lv_obj_set_style_text_font(_battery_label, &lv_font_montserrat_20, 0);
    lv_obj_set_style_text_color(_battery_label, lv_color_hex(COLOR_TEXT_DIM), 0);
    lv_label_set_text(_battery_label, "");

    _date_label = create_label(_digital, &clock_font_cn_28, COLOR_TEXT, -105);
    _time_label = create_label(_digital, &clock_font_digits_120, COLOR_TEXT, -8);
    _lunar_label = create_label(_digital, &clock_font_cn_20, COLOR_LUNAR, 88);

    // Sync state: coloured dot + text
    lv_obj_t *sync_row = create_box(_digital);
    lv_obj_set_size(sync_row, LV_SIZE_CONTENT, LV_SIZE_CONTENT);
    lv_obj_set_flex_flow(sync_row, LV_FLEX_FLOW_ROW);
    lv_obj_set_flex_align(sync_row, LV_FLEX_ALIGN_CENTER, LV_FLEX_ALIGN_CENTER, LV_FLEX_ALIGN_CENTER);
    lv_obj_set_style_pad_column(sync_row, 8, 0);
    lv_obj_align(sync_row, LV_ALIGN_CENTER, 0, 128);
    _sync_dot = create_box(sync_row);
    lv_obj_set_size(_sync_dot, 8, 8);
    lv_obj_set_style_radius(_sync_dot, LV_RADIUS_CIRCLE, 0);
    lv_obj_set_style_bg_opa(_sync_dot, LV_OPA_COVER, 0);
    _sync_label = lv_label_create(sync_row);
    lv_obj_set_style_text_font(_sync_label, &clock_font_cn_20, 0);
    lv_obj_set_style_text_color(_sync_label, lv_color_hex(COLOR_TEXT_DIM), 0);
    lv_label_set_text(_sync_label, "");
}

static lv_obj_t *create_hand(lv_obj_t *dial, int width, uint32_t color)
{
    lv_obj_t *hand = lv_line_create(dial);
    lv_obj_set_style_line_width(hand, width, 0);
    lv_obj_set_style_line_color(hand, lv_color_hex(color), 0);
    lv_obj_set_style_line_rounded(hand, true, 0);
    return hand;
}

static lv_obj_t *create_dot(lv_obj_t *parent, int size, uint32_t color)
{
    lv_obj_t *dot = create_box(parent);
    lv_obj_set_size(dot, size, size);
    lv_obj_set_style_radius(dot, LV_RADIUS_CIRCLE, 0);
    lv_obj_set_style_bg_opa(dot, LV_OPA_COVER, 0);
    lv_obj_set_style_bg_color(dot, lv_color_hex(color), 0);
    lv_obj_center(dot);
    return dot;
}

void Clock::createAnalogFace(lv_obj_t *parent)
{
    _analog = create_box(parent);
    lv_obj_set_size(_analog, LV_PCT(100), LV_PCT(100));

    // Texts first, so the hands are drawn over them
    _a_date_label = create_label(_analog, &clock_font_cn_20, COLOR_ACCENT, -80);
    _a_lunar_label = create_label(_analog, &clock_font_cn_20, COLOR_LUNAR, 80);
    _a_sync_label = create_label(_analog, &clock_font_cn_20, COLOR_ACCENT, 112);

    // 60 ticks, a long one every 5, numbers 1..12
    _dial = lv_scale_create(_analog);
    lv_obj_remove_flag(_dial, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_set_size(_dial, DIAL_SIZE, DIAL_SIZE);
    lv_obj_center(_dial);
    lv_scale_set_mode(_dial, LV_SCALE_MODE_ROUND_INNER);
    lv_scale_set_total_tick_count(_dial, 61);
    lv_scale_set_major_tick_every(_dial, 5);
    lv_scale_set_range(_dial, 0, 60);
    lv_scale_set_angle_range(_dial, 360);
    lv_scale_set_rotation(_dial, 270);
    lv_scale_set_label_show(_dial, true);
    lv_scale_set_text_src(_dial, DIAL_LABELS);
    lv_obj_set_style_arc_opa(_dial, LV_OPA_TRANSP, LV_PART_MAIN);
    lv_obj_set_style_length(_dial, 20, LV_PART_INDICATOR);
    lv_obj_set_style_line_width(_dial, 4, LV_PART_INDICATOR);
    lv_obj_set_style_line_color(_dial, lv_color_hex(COLOR_TEXT), LV_PART_INDICATOR);
    lv_obj_set_style_text_font(_dial, &lv_font_montserrat_32, LV_PART_INDICATOR);
    lv_obj_set_style_text_color(_dial, lv_color_hex(COLOR_TEXT), LV_PART_INDICATOR);
    lv_obj_set_style_length(_dial, 9, LV_PART_ITEMS);
    lv_obj_set_style_line_width(_dial, 2, LV_PART_ITEMS);
    lv_obj_set_style_line_color(_dial, lv_color_hex(COLOR_OFF), LV_PART_ITEMS);

    _hour_hand = create_hand(_dial, 10, COLOR_TEXT);
    _min_hand = create_hand(_dial, 6, COLOR_TEXT);
    _sec_hand = create_hand(_dial, 3, COLOR_ACCENT);

    create_dot(_analog, 20, COLOR_TEXT);
    create_dot(_analog, 8, COLOR_ACCENT);
}

void Clock::showFace(Face face)
{
    _face = face;
    if (face == FACE_DIGITAL) {
        lv_obj_remove_flag(_digital, LV_OBJ_FLAG_HIDDEN);
        lv_obj_add_flag(_analog, LV_OBJ_FLAG_HIDDEN);
    } else {
        lv_obj_add_flag(_digital, LV_OBJ_FLAG_HIDDEN);
        lv_obj_remove_flag(_analog, LV_OBJ_FLAG_HIDDEN);
    }
    refresh(true);
}

void Clock::refreshStatus(bool force)
{
    const int net = sys_net_state();
    const int time_state = sys_time_state();
    int percent = 0;
    bool charging = false;
    const int battery = sys_battery_get(&percent, &charging) ? (percent * 2 + (charging ? 1 : 0)) : -1;

    if (force || net != _last_net_state) {
        _last_net_state = net;
        lv_obj_set_style_text_color(
            _wifi_label, lv_color_hex((net == SYS_NET_CONNECTED) ? COLOR_TEXT : COLOR_OFF), 0
        );

        const char *text;
        uint32_t color;
        if (time_state == SYS_TIME_SYNCED) {
            text = "已同步 · 北京时间";
            color = COLOR_OK;
        } else if (net == SYS_NET_NO_CONFIG) {
            text = (time_state == SYS_TIME_RESTORED) ? "时间未校准 · 未配置网络" : "未配置网络";
            color = COLOR_ERROR;
        } else {
            text = (time_state == SYS_TIME_RESTORED) ? "时间未校准 · 正在联网" : "等待网络校时";
            color = (time_state == SYS_TIME_RESTORED) ? COLOR_ACCENT : COLOR_ERROR;
        }
        lv_label_set_text(_sync_label, text);
        lv_obj_set_style_bg_color(_sync_dot, lv_color_hex(color), 0);
        lv_label_set_text(_a_sync_label, (time_state == SYS_TIME_SYNCED) ? "" : text);
        lv_obj_set_style_text_color(_a_sync_label, lv_color_hex(color), 0);
    }

    if (force || battery != _last_battery) {
        _last_battery = battery;
        if (battery < 0) {
            lv_label_set_text(_battery_label, "");
        } else {
            const char *icon = (percent > 80) ? LV_SYMBOL_BATTERY_FULL :
                               (percent > 55) ? LV_SYMBOL_BATTERY_3 :
                               (percent > 30) ? LV_SYMBOL_BATTERY_2 :
                               (percent > 10) ? LV_SYMBOL_BATTERY_1 : LV_SYMBOL_BATTERY_EMPTY;
            lv_label_set_text_fmt(_battery_label, "%s%s %d%%", charging ? LV_SYMBOL_CHARGE " " : "", icon, percent);
            lv_obj_set_style_text_color(
                _battery_label, lv_color_hex((percent <= 10 && !charging) ? COLOR_ERROR : COLOR_TEXT_DIM), 0
            );
        }
    }
}

void Clock::refresh(bool force)
{
    time_t now = time(nullptr);
    struct tm t = {};
    localtime_r(&now, &t);
    const int time_state = sys_time_state();
    const bool known = (time_state != SYS_TIME_UNSET);
    const bool state_changed = (time_state != _last_time_state);

    if (!force && !state_changed && t.tm_sec == _last_sec) {
        refreshStatus(false);
        return;
    }
    _last_sec = t.tm_sec;

    // Seconds: only the visible face (a hidden object is not redrawn anyway)
    if (_face == FACE_DIGITAL) {
        lv_arc_set_value(_sec_arc, known ? t.tm_sec : 0);
    } else {
        lv_scale_set_line_needle_value(_dial, _sec_hand, SEC_HAND_LEN, t.tm_sec);
    }

    if (force || state_changed || t.tm_min != _last_min) {
        _last_min = t.tm_min;
        if (known) {
            lv_label_set_text_fmt(_time_label, "%02d:%02d", t.tm_hour, t.tm_min);
        } else {
            lv_label_set_text(_time_label, "--:--");
        }
        lv_scale_set_line_needle_value(_dial, _hour_hand, HOUR_HAND_LEN, (t.tm_hour % 12) * 5 + t.tm_min / 12);
        lv_scale_set_line_needle_value(_dial, _min_hand, MIN_HAND_LEN, t.tm_min);
    }

    if (force || state_changed || t.tm_yday != _last_yday) {
        _last_yday = t.tm_yday;
        if (!known) {
            lv_label_set_text(_date_label, "--月--日");
            lv_label_set_text(_lunar_label, "");
            lv_label_set_text(_a_date_label, "");
            lv_label_set_text(_a_lunar_label, "");
        } else {
            const int year = t.tm_year + 1900, month = t.tm_mon + 1, day = t.tm_mday;
            lv_label_set_text_fmt(_date_label, "%d月%d日  星期%s", month, day, WEEKDAYS[t.tm_wday]);
            lv_label_set_text_fmt(_a_date_label, "周%s  %d", WEEKDAYS[t.tm_wday], day);

            lunar_date_t ld;
            if (lunar_from_solar(year, month, day, &ld)) {
                char lunar_date[32], lunar_year[32];
                lunar_format_date(&ld, lunar_date, sizeof(lunar_date));
                lunar_format_year(&ld, lunar_year, sizeof(lunar_year));
                const char *festival = lunar_festival(year, month, day, &ld);
                lv_label_set_text_fmt(_lunar_label, "农历%s · %s", lunar_date, festival ? festival : lunar_year);
                lv_label_set_text(_a_lunar_label, festival ? festival : lunar_date);
                lv_obj_set_style_text_color(_lunar_label, lv_color_hex(festival ? COLOR_ACCENT : COLOR_LUNAR), 0);
            } else {
                lv_label_set_text(_lunar_label, "");
                lv_label_set_text(_a_lunar_label, "");
            }
        }
    }

    _last_time_state = time_state;
    refreshStatus(force || state_changed);
}

void Clock::onTimer(lv_timer_t *timer)
{
    Clock *app = static_cast<Clock *>(lv_timer_get_user_data(timer));
    if (app != nullptr) {
        app->refresh(false);
    }
}

void Clock::onClicked(lv_event_t *e)
{
    Clock *app = static_cast<Clock *>(lv_event_get_user_data(e));
    if (app != nullptr) {
        app->showFace((_face == FACE_DIGITAL) ? FACE_ANALOG : FACE_DIGITAL);
    }
}

bool Clock::run(void)
{
    ESP_UTILS_LOGD("Run");

    // Widgets of a previous run were freed with its screen: start from a clean state
    _last_sec = _last_min = _last_yday = _last_time_state = _last_net_state = -1;
    _last_battery = -2;

    // With `use_default_screen = true`, the core has already created and loaded a
    // default screen. We just draw our UI onto the active screen.
    lv_obj_t *scr = lv_scr_act();
    lv_obj_set_style_bg_color(scr, lv_color_black(), 0);
    lv_obj_set_style_bg_opa(scr, LV_OPA_COVER, 0);
    lv_obj_remove_flag(scr, LV_OBJ_FLAG_SCROLLABLE);

    // Full-screen tap target: tap anywhere to switch between the two faces
    lv_obj_t *root = lv_obj_create(scr);
    lv_obj_remove_style_all(root);
    lv_obj_set_size(root, SCREEN_SIZE, SCREEN_SIZE);
    lv_obj_center(root);
    lv_obj_remove_flag(root, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_add_flag(root, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_add_event_cb(root, onClicked, LV_EVENT_SHORT_CLICKED, this);

    createDigitalFace(root);
    createAnalogFace(root);
    showFace(_face);

    lv_timer_create(onTimer, TIMER_MS, this);

    return true;
}

bool Clock::back(void)
{
    ESP_UTILS_LOGD("Back");

    ESP_UTILS_CHECK_FALSE_RETURN(notifyCoreClosed(), false, "Notify core closed failed");

    return true;
}

// Auto-register this app into the registry so the launcher installs it automatically
// (no need to edit main.cpp).
ESP_UTILS_REGISTER_PLUGIN_WITH_CONSTRUCTOR(systems::base::App, Clock, APP_NAME, []()
{
    return std::shared_ptr<Clock>(Clock::requestInstance(), [](Clock * p) {});
})

} // namespace esp_brookesia::apps
